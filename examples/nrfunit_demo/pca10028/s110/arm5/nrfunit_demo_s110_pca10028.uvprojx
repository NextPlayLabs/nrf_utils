# Keil uVision project nrfunit_demo_s110_pca10028.uvprojx, settings and files
target nrfUnit Demo (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrfunit_demo_s110_pca10028
  c flags: Optim=1 uC99=1 wLevel=2
  c define: __HEAP_SIZE=0 NRF51 BSP_DEFINES_ONLY BOARD_PCA10028 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ../../../: device_main.c all_tests.c ts_example_basic.c ts_example_another.c
    ../../../../../: nrfunit_device.c log4nrf.c
  group ::Board Support
    RTE/Board_Support/nRF51422_xxAC/: bsp.c
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/1.1.0/common/: ble_srv_common.c
    RTE/nRF_BLE/nRF51422_xxAC/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51422_xxAC/: simple_uart.c simple_uart.h
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAC/: app_button.c app_button.h app_error.c app_error.h app_gpiote.c app_gpiote.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h nrf_assert.c nrf_assert.h
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51422_xxAC/: softdevice_handler.c
software components: CMSIS:CORE 3.40.0, Board Support:bsp 7.1.0, Device:Startup 1.0.1, nRF_BLE:BLE_Modules:ble_advdata 1.1.0, nRF_BLE:BLE_Modules:ble_common 1.1.0, nRF_BLE:BLE_Modules:ble_conn_params 1.1.0, nRF_BLE:BLE_Modules:ble_service_common 1.1.0, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Drivers:simple_uart 1.2.0, nRF_Libraries:app_button 1.1.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_gpiote 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:nrf_assert 1.1.0, nRF_SoftDevice:Internal:sd_common 1.1.0, nRF_SoftDevice:Internal:softdevice_present 1.1.0, nRF_SoftDevice:s110 7.1.0-3
