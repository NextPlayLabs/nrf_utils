# Keil uVision project nrfuint_demo.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: log4nrf_demo_s110 +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001 LOG_LEVEL=LOG_LEVEL_DEBUG NRFUNIT_CONTINUE_ON_FAILURE
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ../: device_main.c
  group Libraries
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
    ../../../: nrfunit_device.c log4nrf.c
  group Tests
    ../: ts_example_basic.c ts_example_another.c all_tests.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_beacon +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
